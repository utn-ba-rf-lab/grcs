options:
  parameters:
    author: mdoallo
    comment: |-
      Se invoca así:
      sim_apt_2049.py  --ifie="/mnt/pasadas/wav/IQ.wav" --opath="/home/mdoallo/" 

      La salida son varios archivos:
    generate_options: no_gui
    id: sim_apt_2049
    output_language: python
    run_options: run
    title: Recepción de APT (Satelites NOAA)
  states: {}

blocks:
- name: Desvio
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: FI
  id: variable
  parameters:
    value: '0'
  states: {}
- name: FI_BWD
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: date
  id: variable
  parameters:
    value: datetime.now().strftime("%Y%m%d_%H%M%S-ARG")
  states: {}
- name: file_name
  id: variable
  parameters:
    value: '"NOAA_pass_"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '100'
    rate: '1e-4'
    reference: '.5'
    type: complex
  states: {state: disabled}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '15'
    audio_pass: '5000'
    audio_stop: '7000'
    chan_rate: samp_rate
    deviation: Desvio
    gain: '.8'
    tau: '0'
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: '2400'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate//15
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: opath + "IQ-Mag-1SpS-Float.raw"
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: ./BB-1SpS-Float.raw
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: ./2K4-1SpS-Float.raw
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_2
  id: blocks_file_sink
  parameters:
    file: opath + "FI-Mag-1SpS-Float.raw"
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate*timeout/15)
    type: complex
  states: {state: disabled}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '128'
    type: float
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: '128'
    type: float
  states: {state: disabled}
- name: blocks_integrate_xx_0_0_0
  id: blocks_integrate_xx
  parameters:
    decim: '125'
    type: float
  states: {state: disabled}
- name: blocks_integrate_xx_0_0_1
  id: blocks_integrate_xx
  parameters:
    decim: '125'
    type: float
  states: {state: disabled}
- name: blocks_integrate_xx_0_1
  id: blocks_integrate_xx
  parameters:
    decim: '128'
    type: float
  states: {}
- name: blocks_integrate_xx_0_1_0
  id: blocks_integrate_xx
  parameters:
    decim: '512'
    type: float
  states: {}
- name: blocks_integrate_xx_0_1_1
  id: blocks_integrate_xx
  parameters:
    decim: '125'
    type: float
  states: {}
- name: blocks_integrate_xx_0_2
  id: blocks_integrate_xx
  parameters:
    decim: '500'
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '30'
    max_iter: '300'
    scale: 1/(128*128*125*30)
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '30'
    max_iter: '300'
    scale: 1/30
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(128*125)
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(125*128)
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(500*512)
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*5
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: opath + file_name + date +".wav"
    format: FORMAT_WAV
    samp_rate: int(samp_rate/15)
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: ifile
    nchan: '2'
    repeat: 'False'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: int(samp_rate/15/100)
    long_form: 'True'
    type: ff
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: FI
    decim: '8'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, FI_BWD/2, 2000)
    type: ccc
  states: {}
- name: ifile
  id: parameter
  parameters:
    comment: Rrchivo .raw con las muestras IQ en 2.048 MSpS
    type: str
    value: '"/mnt/pasadas/wav/IQ.wav"'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '40'
    decim: '128'
    gain: '1'
    samp_rate: samp_rate//15
    type: fir_filter_ccf
    width: '40'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: opath
  id: parameter
  parameters:
    comment: Ruta de destino de archivos
    type: str
    value: '"./"'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '15'
    interp: '1'
    type: ccc
  states: {state: disabled}
- name: timeout
  id: parameter
  parameters:
    type: eng_float
    value: '600'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: sigue
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: FI
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: sigue
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: sigue
  states: {state: disabled}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: FI
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_fm_demod_cf_0, '0']
- [analog_fm_demod_cf_0, '0', virtual_sink_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_mag_0, '0', blocks_integrate_xx_0_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_integrate_xx_0_2, '0']
- [blocks_float_to_complex_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_complex_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_float_to_complex_1, '0', blocks_multiply_xx_0, '0']
- [blocks_head_0, '0', blocks_null_sink_0, '0']
- [blocks_integrate_xx_0, '0', blocks_integrate_xx_0_1, '0']
- [blocks_integrate_xx_0_0, '0', blocks_integrate_xx_0_0_1, '0']
- [blocks_integrate_xx_0_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_integrate_xx_0_0_1, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [blocks_integrate_xx_0_1, '0', blocks_integrate_xx_0_1_1, '0']
- [blocks_integrate_xx_0_1_0, '0', blocks_multiply_const_vxx_0_1_0, '0']
- [blocks_integrate_xx_0_1_1, '0', blocks_moving_average_xx_0, '0']
- [blocks_integrate_xx_0_2, '0', blocks_integrate_xx_0_1_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_file_sink_0_2, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_file_sink_0_1, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', blocks_file_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [dc_blocker_xx_0, '0', blocks_null_sink_1, '0']
- [dc_blocker_xx_0, '0', blocks_wavfile_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', virtual_sink_0_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [rational_resampler_xxx_0, '0', blocks_head_0, '0']
- [virtual_source_0, '0', blocks_integrate_xx_0_0, '0']
- [virtual_source_0, '0', dc_blocker_xx_0, '0']
- [virtual_source_0_0, '0', blocks_float_to_complex_1, '0']
- [virtual_source_0_0, '0', blocks_float_to_complex_1, '1']
- [virtual_source_0_1, '0', blocks_complex_to_mag_squared_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
