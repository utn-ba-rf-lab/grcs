options:
  parameters:
    author: mdoallo
    comment: |-
      Se invoca así:
      python3 rx.py --freq=102.3e6 --path="/home/mdoallo/" --rfgain=10
    generate_options: no_gui
    id: rx
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: BB_Gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: FI
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: FI_BWD
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: FI_Gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: date
  id: variable
  parameters:
    value: datetime.now().strftime("%Y%m%d_%H%M%S(ARG)")
  states: {}
- name: file_name
  id: variable
  parameters:
    value: '"NOAA_pass_"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '25'
    audio_pass: '6000'
    audio_stop: '7000'
    chan_rate: samp_rate/5
    deviation: '75000'
    gain: '0.8'
    tau: '75e-6'
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: path + file_name + date +".wav"
    format: FORMAT_WAV
    samp_rate: int(samp_rate/5/25)
  states: {}
- name: freq
  id: parameter
  parameters:
    type: eng_float
    value: 100.7e6
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: FI
    decim: '5'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, FI_BWD/2, 20000)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: path
  id: parameter
  parameters:
    type: str
    value: '"./"'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '128'
    interp: '125'
    type: fff
  states: {}
- name: rfgain
  id: parameter
  parameters:
    type: eng_float
    value: '20'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: BB_Gain
    freq0: freq-FI
    gain0: rfgain
    gain_mode0: 'False'
    if_gain0: FI_Gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_fm_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', blocks_wavfile_sink_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
