options:
  parameters:
    author: Marcelo Doallo
    generate_options: qt_gui
    id: SIM_APT137_Rx
    output_language: python
    title: Simulador de Receptor de NOAA APT 137 MHz
  states: {}

blocks:
- name: Audio_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,3,1,1
    label: Volumen
    start: '0'
    step: '2.5e-2'
    stop: '1'
    value: '0'
    widget: dial
  states: {}
- name: FI_BWD
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    start: 10e3
    step: 2e3
    stop: 60E3
    value: 40e3
    widget: counter
  states: {}
- name: Graba
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: 5,5,1,1
    initPressed: 'False'
    label: Graba
    pressBackgroundColor: red
    pressFontColor: black
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: center
  id: variable
  parameters:
    value: '137.8'
  states: {}
- name: date
  id: variable
  parameters:
    value: datetime.now().strftime("%Y%m%d_%H%M%S(ARG)")
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '5'
  states: {}
- name: fi
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: FI [Hz]
    start: '-samp_rate/2'
    step: '100'
    stop: samp_rate/2
    value: '112500'
    widget: counter
  states: {}
- name: file_name
  id: variable
  parameters:
    value: '"NOAA_pass_"'
  states: {}
- name: path
  id: variable
  parameters:
    value: '"/home/mdoallo/Descargas/"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: sintonia
  id: variable
  parameters:
    value: center*1e6 + fi
  states: {}
- name: sintonia_qtgui_label
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: f''{x:.6f}'''
    gui_hint: 1,0,1,1
    label: 'Sintonia [MHz]: '
    type: real
    value: sintonia / 1e6
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate / decimation) / (2*math.pi*17000)
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_abs_xx_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/mdoallo/Descargas/gqrx_20230801_137800000Hz_2400KSpS.raw
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: int (samp_rate/5)
    vlen_out: '1'
  states: {}
- name: blocks_max_xx_0_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: '1024'
    vlen_out: '1'
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: Audio_Gain
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '.000001'
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: Graba
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int (samp_rate/5)
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: path + file_name + date +".wav"
    format: FORMAT_WAV
    samp_rate: '48000'
  states: {}
- name: entrada
  id: qtgui_number_sink
  parameters:
    avg: '0.25'
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: 0,5,2,1
    label1: Señal
    min: '0'
    name: '"Antena"'
    type: float
    update_time: '0.5'
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '5'
    taps: firdes.low_pass(1.0,240e3,8e3,2e3)
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: fi
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, FI_BWD/2, 20000)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: qt_gui_num_fi
  id: qtgui_number_sink
  parameters:
    avg: '1'
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 2,5,1,1
    label1: Pot. en FI
    min: '0'
    name: ''
    type: float
    unit1: dBFS
    update_time: '0.1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center*1e6
    fftsize: '1024'
    grid: 'True'
    gui_hint: qtgui_tab@0:0,0,5,4
    type: complex
    ymax: '-10'
    ymin: '-110'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate // decimation
    ctrlpanel: 'True'
    fc: sintonia
    fftsize: '2048'
    grid: 'True'
    gui_hint: qtgui_tab@2:0,0,5,4
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: 240e3 / 5
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: qtgui_tab@3:0,0,5,4
    type: float
    ymax: '-20'
    ymin: '-100'
  states: {}
- name: qtgui_number_sink_salida
  id: qtgui_number_sink
  parameters:
    avg: '0.25'
    color1: ("black", "red")
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: 3,5,2,1
    label1: Nivel Ent.
    min: '0'
    type: float
  states: {}
- name: qtgui_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,5,5
    label0: Espectro de RF
    label1: Waterfall de RF
    label2: Espectro Post FI
    label3: Espectro Post Dect
    num_tabs: '4'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center*1e6
    fftsize: '1024'
    gui_hint: qtgui_tab@1:0,0,5,4
    type: complex
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate // decimation)
    interp: '240000'
    type: fff
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_abs_xx_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_file_source_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_file_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_max_xx_0, '0', entrada, '0']
- [blocks_max_xx_0_0, '0', qtgui_number_sink_salida, '0']
- [blocks_multiply_const_vxx_0_1, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_abs_xx_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_selector_0, '0']
- [blocks_nlog10_ff_0, '0', qt_gui_num_fi, '0']
- [blocks_rms_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_selector_0, '0', blocks_null_sink_0, '0']
- [blocks_selector_0, '1', blocks_wavfile_sink_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_max_xx_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_max_xx_0_0, '0']
- [fir_filter_xxx_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [fir_filter_xxx_1, '0', qtgui_freq_sink_x_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_rms_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0, '0', fir_filter_xxx_1, '0']

metadata:
  file_format: 1
