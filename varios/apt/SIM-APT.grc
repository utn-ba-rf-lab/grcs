options:
  parameters:
    author: mdoallo
    comment: |-
      Se invoca así:
      python3 rx_apt.py --freq=137.1e6 --path="/home/mdoallo/" --rfgain=30 --timeout=900

      NOAA-15 137,62 MHz
      NOAA-18 137,9125 MHz
      NOAA-19 137,1
    generate_options: no_gui
    id: rx_apt
    output_language: python
    run_options: run
    title: Recepción de APT (Satelites NOAA)
  states: {}

blocks:
- name: Desvio
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: FI
  id: variable
  parameters:
    value: '0'
  states: {}
- name: FI_BWD
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: date
  id: variable
  parameters:
    value: datetime.now().strftime("%Y%m%d_%H%M%S-ARG")
  states: {}
- name: file_name
  id: variable
  parameters:
    value: '"NOAA_pass_"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '100'
    rate: '1e-4'
    reference: '.5'
    type: complex
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '15'
    audio_pass: '5000'
    audio_stop: '7000'
    chan_rate: samp_rate
    deviation: Desvio
    gain: '.8'
    tau: '0'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate*timeout/15)
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*5
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: path + file_name + date +".wav"
    format: FORMAT_WAV
    samp_rate: int(samp_rate/15)
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/mdoallo/Descargas/sdrangel_20230801_137800000Hz_240KSpS.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: int(samp_rate/15/100)
    long_form: 'True'
    type: ff
  states: {}
- name: freq
  id: parameter
  parameters:
    type: eng_float
    value: 137.62e6
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: FI
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, FI_BWD/2, 2000)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: path
  id: parameter
  parameters:
    type: str
    value: '"./"'
  states: {}
- name: rfgain
  id: parameter
  parameters:
    type: eng_float
    value: '20'
  states: {}
- name: timeout
  id: parameter
  parameters:
    type: eng_float
    value: '600'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: sigue
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: sigue
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_fm_demod_cf_0, '0']
- [analog_fm_demod_cf_0, '0', virtual_sink_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_complex_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_head_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [dc_blocker_xx_0, '0', blocks_head_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [virtual_source_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
