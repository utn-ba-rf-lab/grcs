options:
  parameters:
    author: Marcelo Doallo
    generate_options: qt_gui
    id: APT_Review
    output_language: python
    title: Análisis de APT
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/mdoallo/Descargas/FI-Mag-1SpS-Float.raw
    repeat: 'False'
    type: float
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/mdoallo/Descargas/BB-1SpS-Float.raw
    repeat: 'False'
    type: float
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/mdoallo/Descargas/2K4-1SpS-Float.raw
    repeat: 'False'
    type: float
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: /home/mdoallo/Descargas/IQ-Mag-1SpS-Float.raw
    repeat: 'False'
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '4'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*4000
    type: float
    vlen: '4'
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: '4'
    type: float
  states: {}
- name: qtgui_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,5,5
    label0: RF
    label1: FI
    label2: BB
    label3: RMS
    num_tabs: '4'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    gui_hint: qtgui_tab@1:0,0,5,5
    name: Amplitud (Módulo de Envolvente Compleja) de FI
    size: 2620//4
    srate: samp_rate
    type: float
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: qtgui_tab@2:0,0,5,5
    name: Valor medio de Banda Base
    size: 2620//4
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: qtgui_tab@3:0,0,5,5
    name: Valor 2K4 de Banda Base
    size: 2620//4
    srate: samp_rate
    type: float
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    gui_hint: qtgui_tab@0:0,0,5,5
    name: Amplitud (Módulo de Envolvente Compleja) de RF
    size: 2620//4
    srate: samp_rate
    type: float
    ymin: '0'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_streams_to_vector_0, '1']
- [blocks_file_source_0_0, '0', blocks_streams_to_vector_0, '2']
- [blocks_file_source_0_0_0, '0', blocks_streams_to_vector_0, '3']
- [blocks_file_source_0_1, '0', blocks_streams_to_vector_0, '0']
- [blocks_null_source_0, '0', blocks_streams_to_vector_0, '3']
- [blocks_streams_to_vector_0, '0', blocks_throttle_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_vector_to_streams_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_vector_to_streams_0, '1', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_streams_0, '2', qtgui_time_sink_x_0_0, '0']
- [blocks_vector_to_streams_0, '3', qtgui_time_sink_x_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
