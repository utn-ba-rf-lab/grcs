options:
  parameters:
    author: mdoallo
    comment: |-
      Se invoca así:
      python3 rx_apt.py --freq=137.1e6 --path="/home/mdoallo/" --rfgain=30 --agc=False --timeout=900

      NOAA-15 137,62 MHz
      NOAA-18 137,9125 MHz
      NOAA-19 137,1

      En rf-lab2 ejecutar "grcc RX-APT.grc"
    generate_options: no_gui
    id: rx_apt
    output_language: python
    run_options: run
    title: Recepción de APT (Satelites NOAA)
  states: {}

blocks:
- name: Desvio
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: FI
  id: variable
  parameters:
    value: '0'
  states: {}
- name: FI_BWD
  id: variable
  parameters:
    value: 40e3
  states: {}
- name: date
  id: variable
  parameters:
    value: datetime.now().strftime("%Y%m%d_%H%M%S-ARG")
  states: {}
- name: decim_1
  id: variable
  parameters:
    value: '8'
  states: {}
- name: decim_2
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: agc
  id: parameter
  parameters:
    type: str
    value: 'False'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '100'
    rate: '1e-4'
    reference: '.5'
    type: complex
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: decim_2
    audio_pass: '5000'
    audio_stop: '7000'
    chan_rate: samp_rate/decim_1
    deviation: Desvio
    gain: '.8'
    tau: '0'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: path + "FI-IQ-Mag-1SpS-Float.raw"
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: path + "RF-IQ-Mag-1SpS-Float.raw"
    type: float
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: path + "RF-IQ-Max-1SpS-Float.raw"
    type: float
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate*timeout/(decim_1*decim_2))
    type: complex
  states: {}
- name: blocks_integrate_xx_0_1_0
  id: blocks_integrate_xx
  parameters:
    decim: '512'
    type: float
  states: {}
- name: blocks_integrate_xx_0_1_0_0
  id: blocks_integrate_xx
  parameters:
    decim: '128'
    type: float
  states: {}
- name: blocks_integrate_xx_0_1_0_0_0
  id: blocks_integrate_xx
  parameters:
    decim: '125'
    type: float
  states: {}
- name: blocks_integrate_xx_0_2
  id: blocks_integrate_xx
  parameters:
    decim: '500'
    type: float
  states: {}
- name: blocks_integrate_xx_0_2_0
  id: blocks_integrate_xx
  parameters:
    decim: '128'
    type: float
  states: {}
- name: blocks_max_xx_0_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: 2**12
    vlen_out: '1'
  states: {}
- name: blocks_max_xx_0_0_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: 2**9
    vlen_out: '1'
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '30'
    max_iter: '300'
    scale: 1/(500*512*30)
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '30'
    max_iter: '300'
    scale: 1/(128*128*125*30)
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: 2**12
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: 2**9
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: path + file_name + date +".wav"
    format: FORMAT_WAV
    samp_rate: int(samp_rate/64)
  states: {}
- name: blocks_wavfile_sink_1
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: path + "IQ" + ".wav"
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: int(samp_rate//decim_1)
  states: {}
- name: file_name
  id: parameter
  parameters:
    type: str
    value: '"NOAA_pass_"'
  states: {}
- name: freq
  id: parameter
  parameters:
    type: eng_float
    value: 137.62e6
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: FI
    decim: decim_1
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, FI_BWD/2, 2000)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: path
  id: parameter
  parameters:
    type: str
    value: '"./"'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim_1*decim_2
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    interp: '128'
    type: fff
  states: {}
- name: rfgain
  id: parameter
  parameters:
    type: eng_float
    value: '20'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    agc: 'True'
    center_freq: freq
    gain: rfgain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: timeout
  id: parameter
  parameters:
    type: eng_float
    value: '600'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: sigue
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: FI
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: RF
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: sigue
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: FI
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: FI
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: RF
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_fm_demod_cf_0, '0']
- [analog_fm_demod_cf_0, '0', virtual_sink_0, '0']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_1, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_1, '1']
- [blocks_complex_to_mag_0, '0', blocks_integrate_xx_0_2, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_integrate_xx_0_2_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_head_0_0, '0', blocks_null_sink_0, '0']
- [blocks_integrate_xx_0_1_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_integrate_xx_0_1_0_0, '0', blocks_integrate_xx_0_1_0_0_0, '0']
- [blocks_integrate_xx_0_1_0_0_0, '0', blocks_moving_average_xx_0_0_0, '0']
- [blocks_integrate_xx_0_2, '0', blocks_integrate_xx_0_1_0, '0']
- [blocks_integrate_xx_0_2_0, '0', blocks_integrate_xx_0_1_0_0, '0']
- [blocks_max_xx_0_0, '0', rational_resampler_xxx_1, '0']
- [blocks_max_xx_0_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_file_sink_0, '0']
- [blocks_moving_average_xx_0_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_max_xx_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', blocks_max_xx_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', virtual_sink_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_head_0_0, '0']
- [rational_resampler_xxx_1, '0', blocks_stream_to_vector_0_0_0, '0']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']
- [soapy_rtlsdr_source_0, '0', virtual_sink_0_0_0, '0']
- [virtual_source_0, '0', blocks_wavfile_sink_0, '0']
- [virtual_source_0_0, '0', blocks_complex_to_float_0, '0']
- [virtual_source_0_0_0, '0', blocks_complex_to_mag_0, '0']
- [virtual_source_0_0_0_0, '0', blocks_complex_to_mag_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
