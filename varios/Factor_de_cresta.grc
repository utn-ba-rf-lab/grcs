options:
  parameters:
    author: Marcelo Doallo
    description: Determina el factor de cresta, valores máximos y RMS cada intervalo de un segundo. La entrada es un archivo .wav en 44100 SpS
    generate_options: qt_gui
    id: fc
    output_language: python
    title: Factor de cresta
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: size
  id: variable
  parameters:
    value: 2**16
  states: {}
- name: valor
  id: variable_qtgui_range
  parameters:
    comment: 0,0,1,1
    gui_hint: 0,0,1,1
    label: 'Volumen: '
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: size
    type: float
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: size
    vlen_out: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/size
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: valor
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: size
    type: float
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: size
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: size
    type: float
  states: {}
- name: blocks_transcendental_0
  id: blocks_transcendental
  parameters:
    name: sqrt
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/mdoallo/Descargas/El mareo.wav
    repeat: 'True'
  states: {}
- name: eas_eas_0
  id: eas_eas
  parameters:
    board: 'True'
    device: '"/dev/ttyUSB1"'
    input_type: float
    mode: data
    samp_rate: '48000'
    vref: '4.096'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    comment: 2,0,1,1
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 2,0,1,1
    max: '2'
    min: '0'
    name: '"Valor RMS:"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    comment: 1,0,1,1
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,0,1,1
    max: '2'
    min: '0'
    name: '"Valor máximo:"'
    type: float
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    comment: 3,0,1,1
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 3,0,1,1
    max: '10'
    min: '0'
    name: '"Factor de cresta"'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '441'
    interp: '480'
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: RMS
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: RMS
  states: {}

connections:
- [blocks_divide_xx_0, '0', qtgui_number_sink_0_1, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_max_xx_0, '0', blocks_repeat_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_transcendental_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_integrate_xx_0, '0']
- [blocks_repeat_0, '0', blocks_divide_xx_0, '0']
- [blocks_repeat_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_repeat_0_0, '0', qtgui_number_sink_0, '0']
- [blocks_repeat_0_0, '0', virtual_sink_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_max_xx_0, '0']
- [blocks_transcendental_0, '0', blocks_repeat_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_xx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_xx_0, '1']
- [blocks_wavfile_source_0, '0', blocks_stream_to_vector_0, '0']
- [rational_resampler_xxx_0, '0', eas_eas_0, '0']
- [virtual_source_0, '0', blocks_divide_xx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
