options:
  parameters:
    author: Marcelo Doallo
    comment: |-
      Demo de funcionamiento de Quadrature Demod 
      y su disgregación
    generate_options: qt_gui
    id: Quadrature_Demod_Test
    output_language: python
    title: Quadrature Demodulator
  states: {}

blocks:
- name: frec
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: 'Frecuencia [HZ]:'
    start: '-10'
    step: '1'
    stop: '10'
    value: '0'
  states: {}
- name: fsk_deviation_hz
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: 'Sensibiliad [1/Hz]:'
    start: '5'
    step: '5'
    stop: '100'
    value: '10'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frec
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: samp_rate/(2*math.pi*fsk_deviation_hz)
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,3,1
    size: '1'
    style1: '2'
    type: complex
    update_time: '0.025'
    width1: '3'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,1,3,1
    label1: Quad Demod
    label2: Disgregación
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Modulada
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Modulada
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_sig_source_x_0, '0', virtual_sink_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_xx_0, '0', blocks_complex_to_arg_0, '0']
- [virtual_source_0, '0', blocks_delay_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0, '0', blocks_throttle2_0, '0']
- [virtual_source_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
