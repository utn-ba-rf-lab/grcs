options:
  parameters:
    author: M. Doallo
    generate_options: qt_gui
    id: Phase_Mod_Test
    output_language: python
    title: Prueba de modulación de fase
  states: {}

blocks:
- name: Sensibilidad
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: 'Sensibilidad [x math.pi]:'
    start: '0'
    step: '.1'
    stop: '1'
    value: '0.5'
    widget: counter
  states: {}
- name: entrada
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: 'Valor a la entrada:'
    start: '-1'
    step: '.1'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: entrada
    type: float
  states: {}
- name: analog_phase_modulator_fc_0
  id: analog_phase_modulator_fc
  parameters:
    sensitivity: Sensibilidad*math.pi
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,4,2
    size: '1'
    style1: '1'
    type: complex
    update_time: '0.025'
    width1: '3'
  states: {}

connections:
- [analog_const_source_x_0, '0', analog_phase_modulator_fc_0, '0']
- [analog_phase_modulator_fc_0, '0', blocks_throttle_0, '0']
- [analog_phase_modulator_fc_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
