options:
  parameters:
    author: M. Doallo
    generate_options: qt_gui
    id: Frequency_Mod_Test
    output_language: python
    title: Prueba de modulación de Frecuencia
  states: {}

blocks:
- name: Sensibilidad
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: 'Sensibilidad [Hz]:'
    start: '0'
    step: '.1'
    stop: '1'
    value: '0.5'
    widget: counter
  states: {}
- name: entrada
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: 'Valor a la entrada:'
    start: '-1'
    step: '.1'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: entrada
    type: float
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    comment: |-
      sensitivity : radians/sample = amplitude * sensitivity
      Si quiero que ante una entrada de valor uno,
      La salidad sea de 1 Hz, entonces:
      sensitivity = 2 * pi / sample_rate
    sensitivity: 2*math.pi*Sensibilidad/samp_rate
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,4,2
    size: '1'
    style1: '2'
    type: complex
    update_time: '0.025'
  states: {}

connections:
- [analog_const_source_x_0, '0', analog_frequency_modulator_fc_0, '0']
- [analog_frequency_modulator_fc_0, '0', blocks_throttle_0, '0']
- [analog_frequency_modulator_fc_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
