options:
  parameters:
    author: Marcelo Doallo
    generate_options: qt_gui
    id: Probe_Signal_Test
    output_language: python
    title: Probe Signal Block Test
  states: {}

blocks:
- name: Function_ID
  id: variable_function_probe
  parameters:
    block_id: My_probe
    function_name: level
    poll_rate: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_qtgui_label
  id: variable_qtgui_label
  parameters:
    comment: 0,0,1,1
    formatter: 'lambda x: f''{x:.3f}'''
    gui_hint: 0,0,1,1
    label: 'Level: '
    type: raw
    value: Function_ID
  states: {}
- name: My_probe
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: samp_rate
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/samp_rate
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,1
    gui_hint: 1,0,1,1
    size: 1024*4
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_integrate_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', My_probe, '0']

metadata:
  file_format: 1
