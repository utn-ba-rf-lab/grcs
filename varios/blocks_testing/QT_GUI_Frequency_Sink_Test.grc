options:
  parameters:
    author: M. Doallo
    generate_options: qt_gui
    id: freq_sink_Test
    output_language: python
    title: Demo de QT GUI Frequency Sink
  states: {}

blocks:
- name: amplitud_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Amplitud 1
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0'
  states: {}
- name: amplitud_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Amplitud 2
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0'
  states: {}
- name: frecuencia_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Frecuencia 1
    start: '-samp_rate/2'
    step: '100'
    stop: samp_rate/2
    value: '1000'
  states: {}
- name: frecuencia_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: Frecuencia 2
    start: '-samp_rate/2'
    step: '100'
    stop: samp_rate/2
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '64000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitud_1
    freq: frecuencia_1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: amplitud_2
    freq: frecuencia_2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0,4,4
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
