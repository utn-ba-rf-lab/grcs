options:
  parameters:
    author: mdoallo
    comment: |-
      Este diagrama se complementa con RTL_ADS-B_to_dump1090.grc
      Reproduce lo que grabó RTL_ADS-B_to_dump1090.grc
      La entrada es un archivo wav de dos canales de 2 MSps

      Antes de correr este grc:
      1. Ejecutar "tail -f /home/mdoallo/Descargas/datos.dat"
      2. Correr "RTL_ADS-B_to_dump1090.grc"
      3. Detener "RTL_ADS-B_to_dump1090.grc"
      4. Ejecutar "./dump1090 --ifile /home/mdoallo/Descargas/datos.dat --net --metric"
      5. Correr "ADS-B_to_dump1090-Playback.grc"
      6. Detener "tail -f /home/mdoallo/Descargas/datos.dat"
      7. Ajustar la Ganancia convenientemente
      8. http://127.0.0.1:8080/
    description: Playback de mensajes ADS-B
    generate_options: qt_gui
    id: to_dump1090
    output_language: python
    title: ADS-B
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 1090e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: size
  id: variable
  parameters:
    value: 2**16
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '127.5'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '127.5'
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/mdoallo/Descargas/datos.dat
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_float_to_uchar_0_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: size
    type: float
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: byte
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '125'
    max_iter: '4000'
    scale: 1/125
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '127.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '127.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/size
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_repeat_0_0_0
  id: blocks_repeat
  parameters:
    interp: size
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/mdoallo/Descargas/ADS-B_20261023-193946.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          # def __init__(self, example_param=1.0):  # only default arguments here
          #     """arguments to this function show up as parameters in GRC"""
          #     gr.sync_block.__init__(
          #         self,
          #         name='Embedded Python Block',   # will show up in GRC
          #         in_sig=[np.complex64],
          #         out_sig=[np.complex64]
          #     )
          #     # if an attribute with the same name as a parameter is found,
          #     # a callback is registered (properties work, too).
          #     self.example_param = example_param
          #
          # def work(self, input_items, output_items):
          #     """example: multiply with constant"""
          #     output_items[0][:] = input_items[0] * self.example_param
          #     return len(output_items[0])

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Redondear a un decimal',
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )

          def work(self, input_items, output_items):
              output_items[0][:] = np.round(input_items[0], 1)
              return len(output_items[0])
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: 1,0,4,4
    fc: freq
    fftsize: '1024'
    gui_hint: 1,0,4,4
    type: complex
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    comment: 0,0,1,4
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 0,0,1,4
    label1: Potencia
    min: '0'
    name: Potencia
    type: float
    unit1: dBFS
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: sdr
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: sdr
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: sdr
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_float_to_uchar_0_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_float_0, '1', blocks_multiply_const_vxx_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', virtual_sink_0_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_interleave_0, '0']
- [blocks_float_to_uchar_0_0, '0', blocks_interleave_0, '1']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_interleave_0, '0', blocks_file_sink_0, '0']
- [blocks_moving_average_xx_0_0, '0', epy_block_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_repeat_0_0_0, '0', qtgui_number_sink_2, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [epy_block_0, '0', blocks_repeat_0_0_0, '0']
- [virtual_source_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0_0_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
