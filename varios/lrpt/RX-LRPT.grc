options:
  parameters:
    author: mdoallo
    comment: |-
      Se invoca así: 
      python3 rx_lrpt.py --freq=137.5e6 --path="/home/mdoallo/" --rfgain=35  --file_name="METEOR-M2-4_Casa_" --timeout=900

      Meteor M2 N4 137,5 MHz

      En rf-lab2 ejecutar "grcc RX-LRPT.grc"
    generate_options: no_gui
    id: rx_lrpt
    output_language: python
    run_options: run
    title: Recepción de LRPT (Satelites Meteor)
  states: {}

blocks:
- name: FI_BWD
  id: variable
  parameters:
    value: 80e3
  states: {}
- name: date
  id: variable
  parameters:
    value: datetime.now().strftime("%Y%m%d_%H%M%S-ARG")
  states: {}
- name: decim_1
  id: variable
  parameters:
    value: '16'
  states: {}
- name: decim_2
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: path + file_name + date + "-FI-Hi-IQ-Mag-1SpS-Float.raw"
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: path + file_name + date + "-RF-IQ-Mag-1SpS-Float.raw"
    type: float
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: path + file_name + date + "-RF-IQ-Max-1SpS-Float.raw"
    type: float
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: path + file_name + date + "-FI-Lo-IQ-Mag-1SpS-Float.raw"
    type: float
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate*timeout/(decim_1*decim_2))
    type: complex
  states: {}
- name: blocks_integrate_xx_0_1_0
  id: blocks_integrate_xx
  parameters:
    decim: '256'
    type: float
  states: {}
- name: blocks_integrate_xx_0_1_0_0
  id: blocks_integrate_xx
  parameters:
    decim: '128'
    type: float
  states: {}
- name: blocks_integrate_xx_0_1_0_0_0
  id: blocks_integrate_xx
  parameters:
    decim: '125'
    type: float
  states: {}
- name: blocks_integrate_xx_0_1_0_1
  id: blocks_integrate_xx
  parameters:
    decim: '256'
    type: float
  states: {}
- name: blocks_integrate_xx_0_2
  id: blocks_integrate_xx
  parameters:
    decim: '500'
    type: float
  states: {}
- name: blocks_integrate_xx_0_2_0
  id: blocks_integrate_xx
  parameters:
    decim: '128'
    type: float
  states: {}
- name: blocks_integrate_xx_0_2_1
  id: blocks_integrate_xx
  parameters:
    decim: '500'
    type: float
  states: {}
- name: blocks_max_xx_0_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: 2**12
    vlen_out: '1'
  states: {}
- name: blocks_max_xx_0_0_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: 2**9
    vlen_out: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(500*256)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(128*128*125)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(500*256)
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: 2**12
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: 2**9
    type: float
  states: {}
- name: blocks_wavfile_sink_1
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: path + file_name + "-IQ-Hi" + ".wav"
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: int(samp_rate//decim_1)
  states: {}
- name: blocks_wavfile_sink_1_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: path + file_name + "-IQ-Lo" + ".wav"
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: int(samp_rate//decim_1)
  states: {}
- name: file_name
  id: parameter
  parameters:
    type: str
    value: '"NOAA_pass_"'
  states: {}
- name: freq
  id: parameter
  parameters:
    type: eng_float
    value: 137.62e6
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-400e3'
    decim: decim_1
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, FI_BWD/2, 2000)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: +400e3
    decim: decim_1
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, FI_BWD/2, 2000)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: path
  id: parameter
  parameters:
    type: str
    value: '"./"'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim_1*decim_2
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    interp: '128'
    type: fff
  states: {}
- name: rfgain
  id: parameter
  parameters:
    type: eng_float
    value: '20'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    gain: rfgain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: timeout
  id: parameter
  parameters:
    type: eng_float
    value: '600'
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: FI_Lo
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: RF
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: FI_Hi
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: FI_Hi
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: FI_Hi
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: RF
  states: {}
- name: virtual_source_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: FI_Lo
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: FI_Lo
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_1, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_1, '1']
- [blocks_complex_to_float_0_0, '0', blocks_wavfile_sink_1_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_wavfile_sink_1_0, '1']
- [blocks_complex_to_mag_0, '0', blocks_integrate_xx_0_2, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_integrate_xx_0_2_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_complex_to_mag_0_1, '0', blocks_integrate_xx_0_2_1, '0']
- [blocks_head_0_0, '0', blocks_null_sink_0, '0']
- [blocks_integrate_xx_0_1_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_integrate_xx_0_1_0_0, '0', blocks_integrate_xx_0_1_0_0_0, '0']
- [blocks_integrate_xx_0_1_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_integrate_xx_0_1_0_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_integrate_xx_0_2, '0', blocks_integrate_xx_0_1_0, '0']
- [blocks_integrate_xx_0_2_0, '0', blocks_integrate_xx_0_1_0_0, '0']
- [blocks_integrate_xx_0_2_1, '0', blocks_integrate_xx_0_1_0_1, '0']
- [blocks_max_xx_0_0, '0', rational_resampler_xxx_1, '0']
- [blocks_max_xx_0_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_file_sink_0_1, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_max_xx_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', blocks_max_xx_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', virtual_sink_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', virtual_sink_0_0_1, '0']
- [rational_resampler_xxx_0, '0', blocks_head_0_0, '0']
- [rational_resampler_xxx_1, '0', blocks_stream_to_vector_0_0_0, '0']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [soapy_rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']
- [soapy_rtlsdr_source_0, '0', virtual_sink_0_0_0, '0']
- [virtual_source_0_0, '0', blocks_complex_to_float_0, '0']
- [virtual_source_0_0_0, '0', blocks_complex_to_mag_0, '0']
- [virtual_source_0_0_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [virtual_source_0_0_0_1, '0', blocks_complex_to_mag_0_1, '0']
- [virtual_source_0_0_1, '0', blocks_complex_to_float_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
