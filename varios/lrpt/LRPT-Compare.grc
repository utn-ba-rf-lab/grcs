options:
  parameters:
    author: Marcelo Doallo
    generate_options: qt_gui
    id: LRPT_Campare
    output_language: python
    title: Compración de selañes de LRPT
  states: {}

blocks:
- name: campus
  id: variable
  parameters:
    comment: Filename de Campus
    value: '"Meteor-M2-4_Campus_20250618_153846-ARG-FI-Hi-IQ-Mag-1SpS-Float"'
  states: {}
- name: canales
  id: variable
  parameters:
    value: '2'
  states: {}
- name: casa
  id: variable
  parameters:
    comment: Filename de Casa
    value: '"METEOR-M2-4_Casa_20250618_153801-ARG-FI-Hi-IQ-Mag-1SpS-Float"'
  states: {}
- name: largo
  id: variable
  parameters:
    value: '30'
  states: {}
- name: nbytes
  id: variable
  parameters:
    value: '3600'
  states: {}
- name: path
  id: variable
  parameters:
    value: '"/home/mdoallo/Descargas/"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: |-
      Casa.raw
      Alternatica File: /dev/zero
    file: path + casa +".raw"
    repeat: 'True'
    type: float
  states: {}
- name: blocks_file_source_0_2
  id: blocks_file_source
  parameters:
    comment: |-
      Campus.raw
      Alternatica File: /dev/zero
    file: path + campus +".raw"
    repeat: 'True'
    type: float
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: nbytes//4
    type: float
    vlen: canales
  states: {}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: largo
    max_iter: '300'
    scale: 1/largo
    type: float
    vlen: canales
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: canales
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: canales
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*4000
    type: float
    vlen: canales
  states: {}
- name: blocks_vector_to_streams_0_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: canales
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0,0,5,5
    label1: Casa
    label2: Campus
    name: Amplitud (Módulo de Envolvente Compleja) en FI
    nconnections: '2'
    size: nbytes//4
    srate: samp_rate
    type: float
    ymin: '0'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_streams_to_vector_0, '0']
- [blocks_file_source_0_2, '0', blocks_streams_to_vector_0, '1']
- [blocks_head_0_0, '0', blocks_null_sink_0, '0']
- [blocks_moving_average_xx_0_0_0, '0', blocks_vector_to_streams_0_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_head_0_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_moving_average_xx_0_0_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_throttle_0, '0']
- [blocks_vector_to_streams_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_streams_0_0, '1', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
