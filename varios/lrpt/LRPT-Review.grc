options:
  parameters:
    author: Marcelo Doallo
    generate_options: qt_gui
    id: LRPT_Review
    output_language: python
    title: Análisis de LRPT
  states: {}

blocks:
- name: canales
  id: variable
  parameters:
    value: '4'
  states: {}
- name: largo
  id: variable
  parameters:
    value: '30'
  states: {}
- name: nbytes
  id: variable
  parameters:
    value: '3600'
  states: {}
- name: path
  id: variable
  parameters:
    comment: Path + Filename + "-"
    value: '"/home/mdoallo/Descargas/Meteor-M2-4_Campus_20250617_160017-ARG-"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: FI-IQ-Mag-1SpS-Float.raw
    file: path + "FI-Hi-IQ-Mag-1SpS-Float.raw"
    repeat: 'True'
    type: float
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    comment: |-
      RF-IQ-Max-1SpS-Float.raw
      Alternatica File: /dev/zero
    file: path + "RF-IQ-Max-1SpS-Float.raw"
    repeat: 'True'
    type: float
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    comment: RF-IQ-Mag-1SpS-Float.raw
    file: path + "RF-IQ-Mag-1SpS-Float.raw"
    repeat: 'True'
    type: float
  states: {}
- name: blocks_file_source_0_2
  id: blocks_file_source
  parameters:
    comment: FI-IQ-Mag-1SpS-Float.raw
    file: path + "FI-Lo-IQ-Mag-1SpS-Float.raw"
    repeat: 'True'
    type: float
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: nbytes//4
    type: float
    vlen: canales
  states: {}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: largo
    max_iter: '300'
    scale: 1/largo
    type: float
    vlen: canales
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: canales
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: canales
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*4000
    type: float
    vlen: canales
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: canales
    type: float
  states: {}
- name: blocks_vector_to_streams_0_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: canales
    type: float
  states: {}
- name: qtgui_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,5,5
    label0: RF Max
    label1: RF Mag
    label2: FI Hi
    label3: FI Lo
    num_tabs: '4'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: qtgui_tab@2:0,0,5,5
    label1: Amp FI
    label2: Amp Avg FI
    name: Amplitud (Módulo de Envolvente Compleja) de FI en 137,9 MHz
    nconnections: '2'
    size: nbytes//4
    srate: samp_rate
    type: float
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: qtgui_tab@0:0,0,5,5
    label1: Max
    label2: Max Avg
    name: Amplitud (Módulo Máximo de Envolvente Compleja) de RF
    nconnections: '2'
    size: nbytes//4
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: qtgui_tab@1:0,0,5,5
    label1: Amp
    label2: Amp Avg
    name: Amplitud (Módulo de Envolvente Compleja) de RF
    nconnections: '2'
    size: nbytes//4
    srate: samp_rate
    type: float
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: qtgui_tab@3:0,0,5,5
    label1: Amp FI
    label2: Amp Avg FI
    name: Amplitud (Módulo de Envolvente Compleja) de FI en 137,1 MHz
    nconnections: '2'
    size: nbytes//4
    srate: samp_rate
    type: float
    ymin: '0'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_streams_to_vector_0, '2']
- [blocks_file_source_0_0, '0', blocks_streams_to_vector_0, '0']
- [blocks_file_source_0_1, '0', blocks_streams_to_vector_0, '1']
- [blocks_file_source_0_2, '0', blocks_streams_to_vector_0, '3']
- [blocks_head_0_0, '0', blocks_null_sink_0, '0']
- [blocks_moving_average_xx_0_0_0, '0', blocks_vector_to_streams_0_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_head_0_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_moving_average_xx_0_0_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_throttle_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_vector_to_streams_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_vector_to_streams_0, '1', qtgui_time_sink_x_0_1, '0']
- [blocks_vector_to_streams_0, '2', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_streams_0, '3', qtgui_time_sink_x_0_2, '0']
- [blocks_vector_to_streams_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_vector_to_streams_0_0, '1', qtgui_time_sink_x_0_1, '1']
- [blocks_vector_to_streams_0_0, '2', qtgui_time_sink_x_0, '1']
- [blocks_vector_to_streams_0_0, '3', qtgui_time_sink_x_0_2, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
