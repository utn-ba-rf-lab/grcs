options:
  parameters:
    author: Marcelo Doallo
    generate_options: qt_gui
    id: monitor
    output_language: python
    title: Monitor
  states: {}

blocks:
- name: Graba
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: 4,5,1,1
    initPressed: 'False'
    label: Graba
    pressBackgroundColor: red
    pressFontColor: black
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: date
  id: variable
  parameters:
    value: datetime.now().strftime("%Y%m%d_%H%M%S(ARG)")
  states: {}
- name: file_name
  id: variable
  parameters:
    value: '"Audio_"'
  states: {}
- name: path
  id: variable
  parameters:
    value: '"/home/mdoallo/Descargas/"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: size
  id: variable
  parameters:
    value: samp_rate//2
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_abs_xx_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: size
    vlen_out: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: size
    type: float
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: Graba
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: size
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: path + file_name + date +".wav"
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    gui_hint: qtgui_tab@1:0,0,5,5
    type: float
    ymax: '-20'
    ymin: '-70'
  states: {}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters:
    gui_hint: 3,5,1,1
    offColor: black
    onColor: red
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    color1: ("black", "red")
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 0,5,1,1
    label1: Valor RMS
    min: '0'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    avg: '1'
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: 1,5,2,1
    label1: Nivel Max.
    min: '0'
    type: float
    update_time: '0.1'
  states: {}
- name: qtgui_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,5,5
    label0: Tiempo
    label1: Espectro
    num_tabs: '2'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: qtgui_tab@0:0,0,5,5
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}

connections:
- [Graba, state, qtgui_ledindicator_0, state]
- [audio_source_0, '0', blocks_abs_xx_0_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [audio_source_0, '0', blocks_rms_xx_0, '0']
- [audio_source_0, '0', blocks_selector_0, '0']
- [audio_source_0, '0', qtgui_freq_sink_x_0, '0']
- [audio_source_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_abs_xx_0_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_max_xx_0, '0', blocks_repeat_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_repeat_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_rms_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_selector_0, '0', blocks_null_sink_0, '0']
- [blocks_selector_0, '1', blocks_wavfile_sink_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_max_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
