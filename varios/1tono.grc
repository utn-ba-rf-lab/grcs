options:
  parameters:
    author: M. Doallo
    generate_options: qt_gui
    id: un_tono
    output_language: python
    title: Un tono
  states: {}

blocks:
- name: amplitud
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Amplitud
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0'
  states: {}
- name: frecuencia
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Frecuencia
    start: '100'
    step: '100'
    stop: '5000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frecuencia
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amplitud
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,3,2
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
