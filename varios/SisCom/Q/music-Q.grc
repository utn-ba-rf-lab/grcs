options:
  parameters:
    catch_exceptions: 'False'
    generate_options: qt_gui
    id: serializer_code
    output_language: python
    realtime_scheduling: '1'
    title: Sampling one tone
  states: {}

blocks:
- name: bits
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,3
    label: 'Bits de cuantificación:'
    min_len: '20'
    start: '3'
    step: '1'
    stop: '16'
    value: '16'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_qtgui_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0,1,2
    label: 'Sample rate [m/Sg.]: '
    type: int
    value: samp_rate
  states: {}
- name: valor
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,2
    label: 'Amplitud: '
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.75'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: valor
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/mdoallo/Descargas/El mareo.wav
    repeat: 'True'
  states: {}
- name: eas_eas_0
  id: eas_eas
  parameters:
    board: 'True'
    device: '"/dev/ttyUSB1"'
    input_type: float
    mode: data
    samp_rate: samp_rate
    vref: '4.096'
  states: {}
- name: pdb_gr_pdb_0
  id: pdb_gr_pdb
  parameters:
    companding_key: ulaw
    constant_a: '87.6'
    constant_u: '255'
    nbits: bits
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 1,0,6,7
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '441'
    interp: '480'
    type: fff
  states: {state: bypassed}

connections:
- [blocks_multiply_const_vxx_0, '0', eas_eas_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [pdb_gr_pdb_0, '0', blocks_multiply_const_vxx_0, '0']
- [pdb_gr_pdb_0, '0', qtgui_time_sink_x_0, '0']
- [pdb_gr_pdb_0, '1', blocks_null_sink_0, '0']
- [pdb_gr_pdb_0, '2', blocks_null_sink_0_0, '0']
- [rational_resampler_xxx_0, '0', pdb_gr_pdb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
