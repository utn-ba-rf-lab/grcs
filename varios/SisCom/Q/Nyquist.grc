options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: Frecuencia
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,4
    label: F. de corte
    start: '1000'
    step: '100'
    stop: '20000'
    value: '20000'
  states: {}
- name: Ganancia
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,1
    label: Amplitud
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Ganancia
    type: float
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/mdoallo/Descargas/El mareo.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: Frecuencia
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '300'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: qtgui_tab@0:0,0,5,5
    type: float
    update_time: 1/10
    ymax: '0'
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '27'
    gui_hint: qtgui_tab@1:0,0,5,5
    size: '44100'
    type: float
    update_time: '1'
    xmax: '1'
    xmin: '-1'
  states: {}
- name: qtgui_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,5,5
    label0: FFT
    label1: Histograma
    num_tabs: '2'
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_histogram_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
