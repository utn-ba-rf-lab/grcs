options:
  parameters:
    author: mdoallo
    generate_options: qt_gui
    id: Audiometria
    output_language: python
    title: Audiometria
  states: {}

blocks:
- name: Amplitud
  id: variable_qtgui_range
  parameters:
    label: Amplitud
    start: '0'
    step: '0.05'
    stop: '1'
    value: '.2'
  states: {}
- name: Frecuencia
  id: variable_qtgui_range
  parameters:
    label: Frecuencia
    start: '100'
    step: '100'
    stop: '20000'
    value: '1000'
  states: {}
- name: boton
  id: variable_qtgui_toggle_button_msg
  parameters:
    initPressed: 'False'
    label: boton
    outputmsgname: boton
    pressed: '1'
    released: '0'
    type: bool
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Amplitud
    freq: Frecuencia
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: boton
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
