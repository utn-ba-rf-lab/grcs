options:
  parameters:
    author: mdoallo
    description: Genera un archivo con muestras complejas en formato float 32 (.raw) a partir de un archivo .wav
    generate_options: qt_gui
    id: wav_to_raw
    output_language: python
    title: From .wav to .raw
  states: {}

blocks:
- name: filename
  id: variable
  parameters:
    value: '"Meteor-M2-4_Campus_20251219_160801-IQ-RF"'
  states: {}
- name: path
  id: variable
  parameters:
    value: '"/home/mdoallo/Descargas"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: path+"/"+filename+".raw"
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate*10
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: path+"/"+filename+".wav"
    nchan: '2'
    repeat: 'False'
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_file_sink_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
