options:
  parameters:
    author: Marcelo Doallo
    generate_options: qt_gui
    id: Sim_Rx_AM
    output_language: python
    title: AM Broadcasting Sim
  states: {}

blocks:
- name: Audio_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,3,1,1
    label: Volumen
    start: '0'
    step: '2.5e-2'
    stop: '1'
    value: '0'
    widget: dial
  states: {}
- name: FI_BWD
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Ancho de banda [Hz]
    start: 2e3
    step: 2e3
    stop: 20E3
    value: 10e3
    widget: counter
  states: {}
- name: RF_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: RF ATT
    start: '0.01'
    step: '0.01'
    stop: '1'
    value: '0.01'
    widget: counter
  states: {}
- name: center
  id: variable
  parameters:
    value: '1.15'
  states: {}
- name: center_qtgui_label
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: f''{x:.1f}'''
    gui_hint: 0,0,1,1
    label: 'Centro [KHz]: '
    type: real
    value: center*1e3
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '5'
  states: {}
- name: fi
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Frec. Intermedia [KHz]
    start: '-samp_rate/2'
    step: '100'
    stop: samp_rate/2
    value: '-200000'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1250000'
  states: {}
- name: sintonia
  id: variable
  parameters:
    value: center*1e6 +fi
  states: {}
- name: sintonia_qtgui_label
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: f''{x:.1f}'''
    gui_hint: 1,0,1,1
    label: 'Sintonia [KHz]: '
    type: real
    value: sintonia/1e3
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '5'
    audio_pass: 10e3
    audio_stop: 10.5e3
    chan_rate: samp_rate // decimation
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: |-
      Sampling file
      Available at:
      https://drive.google.com/drive/folders/
      1tpBzL0OpcI2KrdQEuzPgg48fFwdVsN8M
    file: /home/mdoallo/Descargas/1150000Hz-1250000SpS-AM_Broadcastings-BUE.raw
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: int (samp_rate/5)
    vlen_out: '1'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '25000'
    max_iter: '4000'
    scale: 1/25000
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: Audio_Gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: RF_Gain
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int (samp_rate/5)
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: entrada
  id: qtgui_number_sink
  parameters:
    avg: '0.25'
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: 0,5,3,1
    label1: Señal
    min: '0'
    name: '"Antena"'
    type: float
    update_time: '0.5'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: fi
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, FI_BWD/2, 2000)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qt_gui_num_fi
  id: qtgui_number_sink
  parameters:
    avg: '.01'
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 3,5,3,1
    label1: Señal
    min: '0'
    name: ''
    type: float
    unit1: dbFS
    update_time: '0.5'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center*1e6
    fftsize: '1024'
    grid: 'True'
    gui_hint: qtgui_tab@0:0,0,5,4
    type: complex
    ymax: '20'
    ymin: '-80'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate // decimation
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: qtgui_tab@2:0,0,5,4
    label1: Sin AGC
    label2: Con AGC
    name: '"Espectro de FI (con 0 Hz =Sintonía)"'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: 240e3 / 5
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: qtgui_tab@3:0,0,5,4
    type: float
    ymax: '-20'
    ymin: '-100'
  states: {}
- name: qtgui_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,5,5
    label0: Espectro de RF
    label1: Waterfall de RF
    label2: Espectro Post FI
    label3: Espectro Post Dect
    num_tabs: '4'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center*1e6
    fftsize: '1024'
    gui_hint: qtgui_tab@1:0,0,5,4
    type: complex
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate // (decimation*5))
    interp: '48000'
    type: fff
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_am_demod_cf_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0_0, '1']
- [analog_am_demod_cf_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_max_xx_0, '0', entrada, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_nlog10_ff_0, '0', qt_gui_num_fi, '0']
- [blocks_stream_to_vector_0, '0', blocks_max_xx_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_1_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']

metadata:
  file_format: 1
