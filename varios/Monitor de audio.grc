options:
  parameters:
    author: Marcelo Doallo
    generate_options: qt_gui
    id: monitor
    output_language: python
    title: Monitor
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    gui_hint: qtgui_tab@1:0,0,2,2
    type: float
    ymax: '-10'
    ymin: '-60'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    color1: ("black", "red")
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: 0,4,3,1
    label1: Valor RMS
    min: '0'
    type: float
  states: {}
- name: qtgui_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,4,4
    label0: Tiempo
    label1: Espectro
    num_tabs: '2'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: qtgui_tab@0:0,0,2,2
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}

connections:
- [audio_source_0, '0', blocks_rms_xx_0, '0']
- [audio_source_0, '0', qtgui_freq_sink_x_0, '0']
- [audio_source_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_rms_xx_0, '0', qtgui_number_sink_0, '0']

metadata:
  file_format: 1
