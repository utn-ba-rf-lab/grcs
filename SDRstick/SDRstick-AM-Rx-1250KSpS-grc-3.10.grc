options:
  parameters:
    author: Marcelo Doallo
    comment: |-
      Crear un pipe "sdrstick.dat"
      Ejecutar ./sdrstick-udpserv de
      ejecutar este .grc
    generate_options: qt_gui
    id: SDRstick
    output_language: python
    realtime_scheduling: '1'
    title: Receptor con SDRstick
  states: {}

blocks:
- name: bits
  id: variable
  parameters:
    comment: Cantidad de bits del ADC
    value: '14'
  states: {}
- name: center
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: 'Frecuencia central [KHz]: '
    type: real
    value: 550+625
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1250e3
  states: {}
- name: sint
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    start: '-(samp_rate//20e3)*10e3'
    step: 5e3
    stop: (samp_rate//20e3)*10e3
    value: '-225000'
    widget: slider
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,3,1,1
    label: 'Sintonia: '
    type: real
    value: center*1e3+sint
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
    widget: slider
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '1024'
    rate: '1e-3'
    reference: '.8'
    type: complex
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '8000'
    audio_stop: '9000'
    chan_rate: samp_rate/25
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/mdoallo/Descargas/sdrstick.dat
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: (2**(bits-1))-1
    vector_input: 'False'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(samp_rate//10)
    max_iter: '4000'
    scale: 1/int(samp_rate//10)
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: '0.001'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: sint
    decim: '25'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 8000, 4000)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center*1e3
    fftsize: '1024'
    gui_hint: 1,0,2,3
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '0.1'
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: 1,3,2,1
    label1: Señal
    min: '0'
    type: float
    update_time: '0.5'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '24'
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: signal2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: signal2
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_am_demod_cf_0, '0']
- [analog_am_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', virtual_sink_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_0, '0']
- [virtual_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
