options:
  parameters:
    author: Marcelo Doallo
    comment: |-
      1. Ejecutar ./sdrstick-udpserv 
      2. Ejecutar python -u sdrstick.py
    generate_options: no_gui
    id: SDRstick
    output_language: python
    realtime_scheduling: '1'
    title: Receptor con SDRstick
  states: {}

blocks:
- name: bits
  id: variable
  parameters:
    comment: Cantidad de bits del ADC
    value: '14'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1250e3
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/mdoallo/Descargas/sdrstick.dat
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: (2**(bits-1))-1
    vector_input: 'False'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
