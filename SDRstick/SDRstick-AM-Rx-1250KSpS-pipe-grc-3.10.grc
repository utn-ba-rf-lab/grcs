options:
  parameters:
    author: Marcelo Doallo
    comment: |-
      Crear un pipe "sdrstick.dat" y "sdrstick-2.dat"
      Ejecutar ./sdrstick-udpserv 
      Ejecutar este .py (python3 -u SDRstick.py)
      Ejecutar Gqrx con Devive string "file=/home/mdoallo/Descargas/sdrstick-2.dat,rate=1250000"
    generate_options: no_gui
    id: SDRstick
    output_language: python
    realtime_scheduling: '1'
    title: Convierte muestras int16 de SDRstick en Complex Float32
  states: {}

blocks:
- name: bits
  id: variable
  parameters:
    comment: Cantidad de bits del ADC
    value: '14'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/mdoallo/Descargas/sdrstick-2.dat
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/mdoallo/Descargas/sdrstick.dat
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: (2**(bits-1))-1
    vector_input: 'False'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
