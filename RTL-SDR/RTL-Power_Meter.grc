options:
  parameters:
    author: mdoallo
    comment: |-
      Se invoca así: 
      python3 RTL_PM --freq=137.5e6  --rfgain=35  --timeout=900 --Bias-Tee-Power=0

      Meteor M2 N4 137,5 MHz
    generate_options: no_gui
    id: RTL_PM
    output_language: python
    run_options: run
    title: Mide Potencia en RF
  states: {}

blocks:
- name: Var_RF_Pow
  id: variable_function_probe
  parameters:
    block_id: id_RF_Pow
    function_name: level
    poll_rate: '.5'
    value: '0'
  states: {}
- name: decim_1
  id: variable
  parameters:
    value: '2'
  states: {}
- name: decim_2
  id: variable
  parameters:
    value: '4'
  states: {}
- name: intSize
  id: variable
  parameters:
    value: samp_rate//10
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: Bias_Tee_Power
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: FI_BWD
  id: parameter
  parameters:
    type: eng_float
    value: '30000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate*timeout/(decim_1*decim_2))
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    comment: |-
      Average the signal
      power.
    length: intSize
    max_iter: intSize
    scale: 1/intSize
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    comment: |-
      Convert the signal power 
      to logarithmic (decibel)
      scale.
    k: '0'
    n: '10'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: RF Power
    target: round(Var_RF_Pow,1)
  states: {}
- name: freq
  id: parameter
  parameters:
    type: eng_float
    value: 137.9e6
  states: {}
- name: id_RF_Pow
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: FI_BWD/2
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim_1*decim_2
    interp: '1'
    type: ccc
  states: {}
- name: rfgain
  id: parameter
  parameters:
    type: eng_float
    value: '45'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    bias: Bias_Tee_Power == 1
    center_freq: freq
    gain: rfgain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: timeout
  id: parameter
  parameters:
    type: eng_float
    value: '60'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_head_0_0, '0', blocks_null_sink_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', id_RF_Pow, '0']
- [blocks_var_to_msg_0, msgout, blocks_message_debug_0, print]
- [low_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [rational_resampler_xxx_0, '0', blocks_head_0_0, '0']
- [soapy_rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [soapy_rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
