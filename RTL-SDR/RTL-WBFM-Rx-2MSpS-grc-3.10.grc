options:
  parameters:
    author: Marcelo Doallo
    generate_options: qt_gui
    id: RTL_WBFM
    output_language: python
    title: Receptor de WBFM
  states: {}

blocks:
- name: Audio_Gain
  id: variable_qtgui_range
  parameters:
    comment: 0,3,1,1
    gui_hint: 0,3,1,1
    label: Volumen
    start: '0'
    step: '2.5e-2'
    stop: '1'
    value: '0.1'
    widget: dial
  states: {}
- name: FI_BWD
  id: variable_qtgui_range
  parameters:
    comment: 0,1,1,1
    gui_hint: 0,1,1,1
    start: 10e3
    step: 10e3
    stop: 250E3
    value: 200e3
    widget: counter
  states: {}
- name: RF_Gain
  id: variable_qtgui_range
  parameters:
    comment: 0,2,1,1
    gui_hint: 0,2,1,1
    label: RF Gain
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
    widget: counter
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    comment: 0,0,1,1
    gui_hint: 0,0,1,1
    label: 'Sintonia [MHz]: '
    start: '86'
    step: '.1'
    stop: '108'
    value: '102.3'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '2'
    audio_pass: '65000'
    audio_stop: '67000'
    chan_rate: samp_rate/8
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/mdoallo/Descargas/fm.raw
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: samp_rate//8*60
    type: complex
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '1024'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Audio_Gain
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: FI_BWD/2
    decim: '8'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 32e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '4'
    gain: '1'
    samp_rate: samp_rate/16
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: freq*1e6
    fftsize: '1024'
    grid: 'True'
    gui_hint: qtgui_tab@0:0,0,5,5
    type: complex
    ymax: '0'
    ymin: '-80'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate/8
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: qtgui_tab@1:0,0,5,5
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate/16
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: qtgui_tab@2:0,0,5,5
    type: float
    ymax: '-20'
    ymin: '-100'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '1'
    color1: ("blue", "red")
    factor1: 1/1024
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 0,4,1,1
    label1: Señal
    min: '0'
    type: float
    update_time: '0.5'
  states: {}
- name: qtgui_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,5,5
    label0: RF
    label1: Post FI
    label2: Post Dect
    num_tabs: '3'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq*1e6
    gain: RF_Gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', low_pass_filter_1, '0']
- [analog_fm_demod_cf_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_integrate_xx_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_integrate_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_fm_demod_cf_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0, '0', virtual_sink_0, '0']
- [low_pass_filter_1, '0', blocks_multiply_const_vxx_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_complex_to_mag_0, '0']
- [soapy_rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
