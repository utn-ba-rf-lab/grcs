options:
  parameters:
    author: mdoallo
    generate_options: qt_gui
    id: RTL_PM
    output_language: python
    run_options: run
    title: Mide Potencia en RF
  states: {}

blocks:
- name: FI_BWD
  id: variable_qtgui_range
  parameters:
    comment: 0,1,1,1
    gui_hint: 0,1,1,1
    label: 'BWD [KHz]:'
    start: '5'
    step: '1'
    stop: '200'
    value: '30'
    widget: counter
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    comment: 0,0,1,1
    entry_signal: returnPressed
    gui_hint: 0,0,1,1
    label: 'Frec. [Hz]:'
    type: real
    value: 432.6e6
  states: {}
- name: intSize
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: rfgain
  id: variable_qtgui_range
  parameters:
    comment: 0,2,1,1
    gui_hint: 0,2,1,1
    label: 'RF Gain [dB]:'
    start: '0'
    step: '1'
    stop: '50'
    value: '0'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: signalPowerLabel
  id: variable_qtgui_label
  parameters:
    comment: 1,0,1,3
    formatter: 'lambda x: f''{x:.1f}'''
    gui_hint: 1,0,1,3
    label: 'Signal Power (dBFS): '
    type: real
    value: variable_function_probe_signal
  states: {}
- name: variable_function_probe_signal
  id: variable_function_probe
  parameters:
    block_id: probeSignalPower
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: Power_0
  id: Power
  parameters:
    intSize: '200000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    comment: |-
      Average the signal
      power.
    length: intSize
    max_iter: intSize
    scale: 1/intSize
    type: float
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    comment: |-
      Convert the signal power 
      to logarithmic (decibel)
      scale.
    k: '0'
    n: '10'
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: FI_BWD/2*1e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: probeSignalPower
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    gain: rfgain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [Power_0, '0', probeSignalPower, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', probeSignalPower, '0']
- [low_pass_filter_0, '0', Power_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [soapy_rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
