options:
  parameters:
    author: mdoallo
    generate_options: qt_gui
    id: RTL_RX
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: Receptor de DSB-SC
  states: {}

blocks:
- name: Freq
  id: variable_qtgui_range
  parameters:
    comment: 0,2,1,1
    gui_hint: 0,1,1,1
    label: Freq [MHz]
    start: '.1'
    step: '0.01'
    stop: '1500'
    value: '432.5'
    widget: counter
  states: {}
- name: intSize
  id: variable
  parameters:
    value: samp_rate//10
  states: {}
- name: rfgain
  id: variable_qtgui_range
  parameters:
    comment: 0,0,1,1
    gui_hint: 0,0,1,1
    label: 'RF Gain:'
    start: '0'
    step: '1'
    stop: '50'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    comment: 0,3,1,1
    gui_hint: 0,2,1,1
    label: 'Vol:'
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
    widget: counter
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '24000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: intSize
    vlen_out: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: intSize
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab@0
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/10
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: qtgui_tab@1
    type: float
  states: {}
- name: qtgui_number_sink
  id: qtgui_number_sink
  parameters:
    color1: ("black", "red")
    comment: 0,3,1,1
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 0,3,1,1
    min: '0'
    type: float
  states: {}
- name: qtgui_tab
  id: qtgui_tab_widget
  parameters:
    comment: 1,0,4,4
    gui_hint: 1,0,4,4
    label0: Tab 0
    label1: Tab 1
    num_tabs: '2'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '0'
    freq0: Freq*1e6
    gain0: rfgain
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_max_xx_0, '0', qtgui_number_sink, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_max_xx_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_real_0, '0']
- [rtlsdr_source_0, '0', blocks_complex_to_mag_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
