options:
  parameters:
    author: Marcelo Doallo
    generate_options: qt_gui
    id: HackRFOne_IO_Capture
    output_language: python
    title: Receptor de Captura
  states: {}

blocks:
- name: BB_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,1
    label: BB Gain
    start: '0'
    step: '2'
    stop: '62'
    value: '20'
    widget: counter
  states: {}
- name: Bandwidth
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,1,1,1
    label: bandwidth
    label0: Auto
    label1: 1,75 MHz
    label2: 20 MHz
    num_opts: '3'
    option0: '0'
    option1: 1.75e6
    option2: 20e6
    type: real
    value: '0'
  states: {}
- name: FI_BWD
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,3,1,1
    label: Bandwidth [KHz]
    start: '10'
    step: '10'
    stop: samp_rate/(decimation*1e3)
    value: '40'
    widget: counter
  states: {}
- name: FI_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: FI Gain
    start: '0'
    step: '1'
    stop: '47'
    value: '20'
    widget: counter
  states: {}
- name: RF_Gain
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,2,1,1
    label: RF Gain (13 dB)
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: center
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: SDR Center [MHz]
    start: '10'
    step: '0.1'
    stop: '1500'
    value: '100'
    widget: counter
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '40'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Offset Re
    start: '-0.05'
    step: '1e-3'
    stop: '0.05'
    value: '-29e-3'
    widget: counter
  states: {}
- name: offset_Im
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Offset Im
    start: '-0.05'
    step: '1e-3'
    stop: '0.05'
    value: '8e-3'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: sintonia
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: Sintonia [KHz]
    start: '-samp_rate/2e3'
    step: '1'
    stop: samp_rate/2e3
    value: '0'
    widget: counter
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: complex(offset , offset_Im)
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/mdoallo/Descargas/IQ-Capture
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '1024'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: sintonia*1e3
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, FI_BWD*500, 10000)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center*1e6
    fftsize: '1024'
    grid: 'True'
    gui_hint: qtgui_tab@0:0,0,5,5
    name: '"Espectro de Entrada"'
    type: complex
    ymax: '-10'
    ymin: '-110'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate / decimation
    ctrlpanel: 'True'
    fc: center*1e6+sintonia*1e3
    fftsize: '1024'
    grid: 'True'
    gui_hint: qtgui_tab@1:0,0,5,5
    name: '"Espectro de FI"'
    type: complex
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    avg: '1'
    color1: ("black", "red")
    factor1: 1/1024
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,4,1,1
    label1: Nivel Ent.
    min: '0'
    type: float
  states: {}
- name: qtgui_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,5,5
    label0: Espectro de RF
    label1: Espectro de FI
    num_tabs: '2'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: RF_Gain
    bandwidth: Bandwidth
    center_freq: center*1e6
    gain: FI_Gain
    samp_rate: samp_rate
    type: fc32
    vga: BB_Gain
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_integrate_xx_0, '0']
- [blocks_integrate_xx_0, '0', qtgui_number_sink_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_file_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [soapy_hackrf_source_0, '0', blocks_add_const_vxx_0, '0']
- [soapy_hackrf_source_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
