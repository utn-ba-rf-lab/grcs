options:
  parameters:
    author: Marcelo Doallo
    generate_options: qt_gui
    id: HackRFOne_WBFM
    output_language: python
    title: Receptor de WBFM
  states: {}

blocks:
- name: Audio_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,3,1,1
    label: Volumen
    orient: Qt.Horizontal
    start: '0'
    step: '2.5e-2'
    stop: '1'
    value: '0'
    widget: dial
  states: {}
- name: BB_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,1
    label: BB Gain
    orient: Qt.Horizontal
    start: '0'
    step: '2'
    stop: '62'
    value: '20'
    widget: counter
  states: {}
- name: Bandwidth
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,2,1,1
    label: bandwidth
    label0: Auto
    label1: 1,75 MHz
    label2: 20 MHz
    num_opts: '3'
    option1: 1.75e6
    option2: 20e6
    type: real
    value: '0'
  states: {}
- name: FI_BWD
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    orient: Qt.Horizontal
    start: 10e3
    step: 10e3
    stop: 250E3
    value: 250e3
    widget: counter
  states: {}
- name: FI_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: FI Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '47'
    value: '20'
    widget: counter
  states: {}
- name: RF_Gain
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 0,2,1,1
    label: RF Gain (13 dB)
    'true': '13'
    type: real
    value: '0'
  states: {}
- name: fi
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0,1,1
    label: 'Sintonia '
    type: real
    value: 100.7e6
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Offset Re
    orient: Qt.Horizontal
    start: '-0.05'
    step: '1e-3'
    stop: '0.05'
    value: '-29e-3'
    widget: counter
  states: {}
- name: offset_Im
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Offset Im
    orient: Qt.Horizontal
    start: '-0.05'
    step: '1e-3'
    stop: '0.05'
    value: '8e-3'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '4'
    audio_pass: '65000'
    audio_stop: '67000'
    chan_rate: samp_rate/10
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fi
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: complex(offset , offset_Im)
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: '0.001'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Audio_Gain
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '2000'
    long_form: 'True'
    type: ff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: FI_BWD/2
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 32e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '5'
    gain: '1'
    samp_rate: samp_rate/40
    type: fir_filter_fff
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: BB_Gain
    bw0: Bandwidth
    freq0: freq+fi
    gain0: RF_Gain
    gain_mode0: 'True'
    if_gain0: FI_Gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: freq
    fftsize: '800'
    grid: 'True'
    gui_hint: qtgui_tab@0:0,0,5,5
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-80'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate/10
    fc: freq
    fftsize: '800'
    grid: 'True'
    gui_hint: qtgui_tab@1:0,0,5,5
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate/40
    fc: '0'
    fftsize: '2000'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: qtgui_tab@2:0,0,5,5
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-20'
    ymin: '-100'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '1'
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,4,1,1
    label1: Señal
    min: '0'
    type: float
    update_time: '0.5'
  states: {}
- name: qtgui_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,5,5
    label0: RF
    label1: Post FI
    label2: Post Dect
    num_tabs: '3'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '4'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', dc_blocker_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [dc_blocker_xx_0, '0', low_pass_filter_1, '0']
- [dc_blocker_xx_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [low_pass_filter_0, '0', analog_fm_demod_cf_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_1, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', blocks_add_const_vxx_0, '0']
- [osmosdr_source_0, '0', blocks_complex_to_mag_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
