options:
  parameters:
    author: Marcelo Doallo
    generate_options: qt_gui
    id: HackRFOne_FM
    output_language: python
    title: Receptor de Modulación exponencial amplio
  states: {}

blocks:
- name: Audio_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,5,1,1
    label: Volumen
    start: '0'
    step: '2.5e-2'
    stop: '1'
    value: '0'
    widget: dial
  states: {}
- name: BB_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,1
    label: BB Gain
    start: '0'
    step: '2'
    stop: '62'
    value: '20'
    widget: counter
  states: {}
- name: Bandwidth
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,1,1,1
    label: RF Bbandwidth
    label0: Auto
    label1: 1,75 MHz
    label2: 20 MHz
    num_opts: '3'
    option0: '0'
    option1: 1.75e6
    option2: 20e6
    type: real
    value: '0'
  states: {}
- name: DE
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,4,1,1
    label: Deenfasis
    label0: 'Off'
    label1: 75 uSec.
    label2: 530 uSec.
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: real
    value: '0'
  states: {}
- name: Desvio
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,3,1,1
    label: Desv. Frec.
    label0: 5 KHz
    label1: 17 KHz
    label2: 25 KHz
    label3: 75 KHz
    num_opts: '4'
    option0: 5e3
    option1: 17e3
    option2: 25e3
    option3: 75e3
    type: real
    value: 5e3
  states: {}
- name: FI_BWD
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: FI bandwidth [KHz]
    start: '10'
    step: '5'
    stop: '250'
    value: '200'
    widget: counter
  states: {}
- name: FI_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: FI Gain
    start: '0'
    step: '1'
    stop: '47'
    value: '20'
    widget: counter
  states: {}
- name: RF_Gain
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 0,2,1,1
    label: RF Gain (13 dB)
    'true': '40'
    type: real
    value: '0'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '20'
  states: {}
- name: fi
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Sintonia [MHz]
    start: '88'
    step: '0.001'
    stop: '150'
    value: '137.62'
    widget: counter
  states: {}
- name: freq_sdr
  id: variable
  parameters:
    value: freq*1e6 - fi
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Offset Re
    start: '-0.05'
    step: '1e-3'
    stop: '0.05'
    value: '-29e-3'
    widget: counter
  states: {}
- name: offset_Im
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Offset Im
    start: '-0.05'
    step: '1e-3'
    stop: '0.05'
    value: '8e-3'
    widget: counter
  states: {}
- name: piloto_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '19020'
    low_cutoff_freq: '18980'
    samp_rate: '240000'
    type: complex_band_pass
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '1.0'
    gain: '1.0'
    ntaps: '151'
    samp_rate: '19000'
    sym_rate: 19000/8
  states: {}
- name: rrc_taps_manchester
  id: variable
  parameters:
    value: '[rrc_taps[n] - rrc_taps[n+8] for n in range(len(rrc_taps)-8)]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: analog_fm_deemph_0_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: '48000'
    tau: '75e-6'
  states: {}
- name: analog_fm_deemph_0_0_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: '48000'
    tau: '530e-6'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate / decimation) / (2*math.pi*Desvio)
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: complex(offset , offset_Im)
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: '1024'
    vlen_out: '1'
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: Audio_Gain
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: DE
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: float
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '5'
    taps: firdes.low_pass(1.0,240000,15e3,2e3)
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: fi
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, FI_BWD*500, 20000)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: BB_Gain
    bw0: Bandwidth
    freq0: freq_sdr
    gain0: RF_Gain
    gain_mode0: 'True'
    if_gain0: FI_Gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: freq_sdr
    fftsize: '1024'
    grid: 'True'
    gui_hint: qtgui_tab@0:0,0,5,5
    name: '"Espectro de Entrada"'
    type: complex
    ymax: '-10'
    ymin: '-110'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate / decimation
    fc: freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: qtgui_tab@1:0,0,5,5
    name: '"Espectro de FI"'
    type: complex
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    avg: '0.1'
    color1: ("black", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 0,5,1,1
    label1: Nivel Ent.
    min: '0'
    type: float
  states: {}
- name: qtgui_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,6,6
    label0: Espectro de RF
    label1: Espectro de FI
    num_tabs: '2'
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate // decimation)
    interp: '240000'
    type: fff
  states: {}

connections:
- [analog_fm_deemph_0_0_0, '0', blocks_selector_0, '1']
- [analog_fm_deemph_0_0_0_0, '0', blocks_selector_0, '2']
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_add_const_vxx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_max_xx_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', audio_sink_0_0, '0']
- [blocks_selector_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_stream_to_vector_0, '0', blocks_max_xx_0, '0']
- [fir_filter_xxx_1, '0', analog_fm_deemph_0_0_0, '0']
- [fir_filter_xxx_1, '0', analog_fm_deemph_0_0_0_0, '0']
- [fir_filter_xxx_1, '0', blocks_selector_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [osmosdr_source_0, '0', blocks_add_const_vxx_0, '0']
- [osmosdr_source_0, '0', blocks_complex_to_mag_0, '0']
- [rational_resampler_xxx_0_0, '0', fir_filter_xxx_1, '0']

metadata:
  file_format: 1
